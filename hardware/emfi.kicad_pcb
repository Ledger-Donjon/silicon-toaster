# Repository Ledger-Donjon/silicon-toaster

File README.md:

# SiliconToaster

SiliconToaster is an open-source hardware electromagnetic fault injection device, designed for hardware security research. It has the following features:

- Software programmable voltage, from 0 V to 1000 V.
- Stored energy: 1 J at 1000 V.
- Capable of multiple fault injection.
- Dual socket coil mounting, for polarity selection.
- USB-only powered.

**Warning: this device is experimental and for research purpose only. High-voltage is exposed on the PCB, which can present electrical hazard. Use with caution and at your own risk. Beware that the coil body is connected to the high potential, NOT at the ground. Also, the exposed capacitor bank stores an important amount of energy.**

## Building the firmware

To build the firmware, rust shall be installed on your system (see [instructions](https://www.rust-lang.org/tools/install) for installation).

The rust toolchain for Armv6-M Thumb must be installed:

```
rustup target add thumbv6m-none-eabi
```

The firmware can then be compiled using cargo:

```
cd firmware
cargo objcopy --release --bin silicontoaster -- -O binary silicontoaster.bin
```

To flash the device, stm32flash utility is required. The MCU bootloader can be enabled by shorting the header close to the USB connector using a jumper, before connecting the PCB on USB. Then the following command will flash the MCU (replace `/dev/ttyUSB0` with the serial device in your situation):

```
stm32flash -w silicontoaster.bin -v -g 0 /dev/ttyUSB0
```

Alternatively, a makefile can run those steps:

```
cd firmware
make all
make flash
```

To enable device recognition, the FTDI USB-serial converter must be flashed using ftdi_eeprom tool. Warning: be sure no other FTDI device is connected before running this command!

```
cd ftdi
bash flash.sh
```

## Running the software

To use the device, run `python3 silicontoaster/tool.py`. This will run a graphical interface that allows setting the operating voltage and display in real-time the voltage in the capacitors bank.

When running for the first time, configure the charge pump PID settings to `Kp`, `Ki` and `Kd` to 1. Be sure to have the jumper J5 installed (position closest to the USB).

The provided calibration values should work fine by default, it is not necessary to calibrate the device by yourself unless you want more accurate measurements.

## Publication

This work was published in our [Paper](https://eprint.iacr.org/2020/1115.pdf) and presented during [Hardwear.io 2020 conference](https://hardwear.io/archives/netherlands-2020/).

## Licensing

SiliconToaster is released under GNU Lesser General Public License version 3 (LGPLv3). See LICENSE and LICENSE.LESSER for license detail.

## Contributions

You are really welcomed to contribute to this project, by giving your feedbacks through Issues, and propose some changes with Pull Requests.

We would like to thank following contributors for this project:

- Sven Freud, from Germany

## KiCad design hardware/emfi.kicad_pcb

Parts:
C1, C42: 100n; C_0603_1608Metric; Voltage 25
J1: USB_B_Micro; USB_Micro-B_Wuerth_629105150521
J2, J3, J6: Conn_Coaxial; SAMTEC_SMA_J_P_H_ST_EM3
J7: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
L1: Ferrite_Bead_Small; L_0603_1608Metric
LOGO1: DUNGEON_LOGO; donjon-2000
R7: 10k; R_0603_1608Metric
U8: 74LVC1G32; SOT-353_SC-70-5

Connections:
+3V3: C42.2, J7.1, U8.5 (VCC); also elsewhere on the board
+5V: L1.2; also elsewhere on the board
/VBUS: C1.2, J1.1 (VBUS), L1.1
/analog/ANTENNA_A: J3.1 (In), J6.2 (Ext); also elsewhere on the board
/analog/ANTENNA_B: J3.2 (Ext), J6.1 (In); also elsewhere on the board
/analog/SHOOT: U8.4; also elsewhere on the board
/ft232/USBD+: J1.3 (D+); also elsewhere on the board
/ft232/USBD-: J1.2 (D-); also elsewhere on the board
/mcu/SW_SHOOT: U8.1; also elsewhere on the board
GND: C1.1, C42.1, J1.5 (GND), J1.6 (Shield), J2.2 (Ext), J7.2, R7.2, U8.3 (GND); also elsewhere on the board
unnamed: J2.1 (In), R7.1, U8.2

Notes on the sheet:
Positive pulse to shoot
PWR connector for external access
Injection probe connectors

Parts:
C9: 100n; C_0603_1608Metric; Voltage 25
U2: FT232RL; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+3V3: U2.4 (VCCIO), U2.20 (VCC); also elsewhere on the board
/ft232/RX: U2.5 (RXD); also elsewhere on the board
/ft232/TX: U2.1 (TXD); also elsewhere on the board
/ft232/USBD+: U2.15 (USBD+); also elsewhere on the board
/ft232/USBD-: U2.16 (USBD-); also elsewhere on the board
GND: C9.2, U2.7 (GND), U2.18 (GND), U2.21 (GND), U2.25 (AGND), U2.26 (TEST); also elsewhere on the board
unnamed: C9.1, U2.17 (3V3OUT)

Parts:
C2, C3, C4, C5, C8, C17: 100n; C_0603_1608Metric; Voltage 25
C6, C7: 2.2µ; C_0603_1608Metric; Voltage 25
D7: red; D_0603_1608Metric
D8: green; D_0603_1608Metric
J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R1, R4: 10k; R_0603_1608Metric
R8, R10: 64.9; R_0603_1608Metric
U1: STM32F205RETx; LQFP-64_10x10mm_P0.5mm

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C8.1, C17.1, J4.2, U1.1 (VBAT), U1.7 (NRST), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD); also elsewhere on the board
/ft232/RX: U1.42 (PA9); also elsewhere on the board
/ft232/TX: U1.43 (PA10); also elsewhere on the board
/mcu/20V_EN: R1.2, U1.30 (PB11); also elsewhere on the board
/mcu/ADC123_IN0: U1.14 (PA0); also elsewhere on the board
/mcu/SW_SHOOT: U1.46 (PA13); also elsewhere on the board
/mcu/TIM1_CH1: U1.41 (PA8); also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C17.2, D7.1 (K), D8.1 (K), R1.1, R4.1, U1.12 (VSSA), U1.18 (VSS), U1.28 (PB2), U1.63 (VSS); also elsewhere on the board
unnamed: D7.2 (A), R8.1
unnamed: D8.2 (A), R10.1
unnamed: J4.1, R4.2, U1.60 (BOOT0)
unnamed: R8.2, U1.2 (PC13)
unnamed: R10.2, U1.3 (PC14)
unnamed: C6.1, U1.31 (VCAP_1)
unnamed: C7.1, U1.47 (VCAP_2)

Notes on the sheet:
Short to enable ST bootloader

Parts:
C10, C11, C12, C13, C14: 2.2µ; C_0603_1608Metric; Voltage 25
C15: 22u; C_0805_2012Metric; Voltage 25
C16: 100n; C_0603_1608Metric; Voltage 25
D5: MBRM140T3; D_Powermite_AK
L2: 10µ; L_1812_4532Metric
R5: 22.1k; R_0603_1608Metric
R6: 2k; R_0603_1608Metric
U3: MIC2288; SOT-23-5
U4, U5: LD1117S33TR_SOT223; SOT-223-3_TabPin2

Connections:
+3V3: C14.1, U5.2 (VO); also elsewhere on the board
+3V3A: C13.1, U4.2 (VO); also elsewhere on the board
+5V: C10.1, C11.1, C12.1, L2.1, U3.5 (VIN), U4.3 (VI), U5.3 (VI); also elsewhere on the board
+15V: C15.1, C16.2, D5.1 (K), R5.1; also elsewhere on the board
/mcu/20V_EN: U3.4 (EN); also elsewhere on the board
GND: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, R6.2, U3.2 (GND), U4.1 (GND), U5.1 (GND); also elsewhere on the board
unnamed: D5.2 (A), L2.2, U3.1 (SW)
unnamed: R5.2, R6.1, U3.3 (FB)

Notes on the sheet:
330 µC
Vout = 1.24 x (R5/R6 + 1) R6 <= 5k

Parts:
C18, C19, C20, C21: 150n; C_2225_5664Metric_Pad1.80x6.60mm_HandSolder; Voltage 1000
D1, D2, D3, D4, D6, D9: US1K-E3/61T; D_SMA_Handsoldering
J5: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J8: Measurement connector; PinSocket_1x02_P2.54mm_Vertical
Q1: STT6N3LLH6; SOT-23-6
Q2: IKW40N120H3FKSA1; TO-247-3_Horizontal_TabDown_NoTabDrill
R2, R11: 10M; R_0603_1608Metric
R3: 10k; R_0603_1608Metric
R9: 4.99; R_0603_1608Metric
T1: CST2010; Transformer_Coilcraft_CST2010
U6: MCP1407-E/SN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3A: J5.3; also elsewhere on the board
+15V: J5.1, U6.1 (VDD), U6.8 (VDD); also elsewhere on the board
/analog/ANTENNA_A: D6.1 (K), D9.1 (K), R2.1; also elsewhere on the board
/analog/ANTENNA_B: D9.2 (A), Q2.2 (C); also elsewhere on the board
/analog/SHOOT: U6.2 (INPUT); also elsewhere on the board
/mcu/ADC123_IN0: J8.1, R2.2, R3.1; also elsewhere on the board
/mcu/TIM1_CH1: Q1.3, R11.1; also elsewhere on the board
GND: C19.1, D1.2 (A), J8.2, Q1.4, Q2.3 (E), R3.2, R11.2, T1.2, U6.4 (GND), U6.5 (GND); also elsewhere on the board
unnamed: C18.2, T1.4
unnamed: C18.1, C20.2, D1.1 (K), D2.2 (A)
unnamed: C19.2, C21.2, D2.1 (K), D3.2 (A)
unnamed: C20.1, D3.1 (K), D4.2 (A)
unnamed: C21.1, D4.1 (K), D6.2 (A)
unnamed: J5.2, T1.12
unnamed: Q1.1, Q1.2, Q1.5, Q1.6, T1.11
unnamed: Q2.1 (G), R9.1
unnamed: R9.2, U6.6 (OUT), U6.7 (OUT)

Notes on the sheet:
10x ceramic capacitors
Gate charge = 185 nC VGE = 15 V C = 1 nF
If the gate if floating when not driven by the MCU (for example when reprogramming the device), it may charge overtime... A high impedance pull-down may help.
For the routing of this sheet, there must be enough insulation between high-voltage tracks and other signals to prevent air electrical breakdown (3 kV / mm) For the same reason, the PCB thickness must be > 1mm
1000 V rated capacitors
Bridge to adapt voltage to ADC input range. Also acts a bleeding resistors for safety.

Parts:
C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41: 100n; C_2225_5664Metric_Pad1.80x6.60mm_HandSolder; Voltage 1500

Connections:
/analog/ANTENNA_A: C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2; also elsewhere on the board
GND: C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1; also elsewhere on the board

Board: 2 copper layers, 132.5 x 38.0 mm, 83 parts (19 on the bottom side), 37 nets.

## Code that names these connections

File firmware/src/main.rs (part):

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    setup_pll(rcc);

    rcc.apb2enr.write(|w| w.usart1en().set_bit());
    // USART1 uses PA9 for TX and PA10 for RX.
    // LEDs are connected to PC13 and PC14.
    // Enable clock for PORT A, PORT B and PORT C peripherals.
    rcc.ahb1enr.write(|w| {
        w.gpioaen()
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            .div_fraction()
            .bits((brr_value & 0x0f) as u8)
    });
    // Select Alternate Function 7 (USART1) for PA9 and PA10.
    let gpioa = &peripherals.GPIOA;
    gpioa.afrh.write(|w| w.afrh10().af7().afrh9().af7());
    gpioa
        .moder
        .write(|w| w.moder10().alternate().moder9().alternate());
    // Configure PA9 and PA10 GPIOs in high frequency
    gpioa
        .ospeedr
        .write(|w| w.ospeedr10().very_high_speed().ospeedr9().very_high_speed());
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        cortex_m::peripheral::NVIC::unmask(stm32f215::Interrupt::USART1);
    }

    // Configure SW_SHOOT signal on pin PA13.
    gpioa.ospeedr.modify(|_, w| w.ospeedr13().very_high_speed());
    gpioa.moder.modify(|_, w| w.moder13().output());

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    let mut adc_ctrl = ADCControl::new();

    // Configure PWM using TIM1.
    // PWM output on PA8. Alternate Function 1.
    peripherals.RCC.apb2enr.modify(|_, w| w.tim1en().set_bit());
    let tim1 = &peripherals.TIM1;
    tim1.cr1.write(|w| w.cen().set_bit());
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    gpioa.moder.modify(|_, w| w.moder8().alternate());

    // Configure ADC.
    // Input is PA0.
    peripherals.RCC.apb2enr.modify(|_, w| w.adc1en().set_bit());
    gpioa.moder.modify(|_, w| w.moder0().analog());
    let adc1 = &peripherals.ADC1;
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
## Commit log

2019-10-29 First hardware version.
2019-11-07 Firmware bootstrap in Rust.
2019-11-08 Clean-up and improvements in firmware.
2019-11-08 Work on firmware.
2019-11-12 Enable PWM output on PA8.
2019-11-12 Minor code improvement.
2019-11-12 Bug fix in UART byte transmission.
2019-11-13 Added software with UX.
2019-11-14 Enabled PLL to run at 64 MHz.
    This allows finer PWM parameters tuning.
2019-11-14 Hardware fix.
    Added pull-down resistor on PWM output of the MCU so the charge pump
    gate does not get charged when the PWM pin is floating.
2019-11-14 Added average and standard deviation in UX.
2019-11-15 Fixed IGBT footprint.
2019-11-19 Software improvements.
    Added precise calibration to read the voltage for the current toaster.
    Now turning off the toaster when closing the tool.
2019-12-16 Improved firmware.
    Always enabling 15 V regulator to prevent USB crashes.
    Red and green LEDs state depending on ADC readout voltage for more
    safety: green is lit when the voltage on the capacitors is < 50 V and
    the charge pump is disabled.
2019-12-17 tty device from program arguments
2020-11-26 Fixed script.ld
2020-11-26 dos2unix script.ld
2022-02-28 Upgraded files for KiCad 6
2022-02-28 Fixed 3D models in KiCad PCB
2022-09-15 Packaging silicon-toaster
2022-09-15 Instanciate silicontoaster by serial number
2022-09-15 Add a software limit, if exists, at each voltage reading, turns the silicon toaster off if it exceeds the limit
2022-09-15 Script to measure the resulting voltage for a given width/period PWM settings
2022-09-15 Turn the silicon toaster off when deleting the object
2022-09-22 Rustfmt
2022-09-22 Implementation of SystemTimer to get timing information: (SysTick of Cortex-M)
2022-09-22 Implementation of ADCControlParams to handle Control of ADC
2022-09-22 Utility functions to transmit/receive up to 64 bits Big Endian words
2022-09-22 Keep track of PWM period/width and add command to retrieve them
2022-09-22 Instanciate a SystemTimer, add a command to get current timestamp
2022-09-22 Instantiate a ADCControl, add a commands to get/set parameters and control
2022-09-22 Running black on Python files
2022-09-22 Integrate the ADC Control in the main loop.
2022-09-22 Add interpolation from calibration log.
2022-09-22 Bad implementation of adjust
2022-09-22 Rewrite needscontrol for more clarity
2022-09-26 Usage of stm32f215::STK for accessing to the Systick register
2022-09-28 panic function: make it blink, and power off high voltage.
2022-09-28 Move out ADC_Control object to mod file
2022-09-28 Add a Flash object controller to store/read values in flash
2022-09-28 Move SystemTimer out of main.rs
2022-09-29 ADC control
2022-09-29 Move transmission function out of main.rs and create TxRx trait with generics rx and tx functions.
2022-09-29 Default PWM period changed to 800
2022-09-29 Get current SystemTimer's tick and time
2022-09-29 Performing 'black'
2022-09-29 SystemTimer
2022-09-29 Command to get and set PID's coefs + the number of ticks between each PID feeding. Optionally stores those parameters in NVM Flash
2022-09-29 Typo
2022-09-29 Union
2022-09-29 ADC Control commands
2022-09-29 Update calibration script to also compute the Volt->RAW polynom
2022-09-29 Ensure in from_bytes that we are dealing with unsigned
2022-09-29 struct import
2022-09-29 Update the setup/configuration files
2022-09-29 Add calibration values to reverse the conversion from Volts to RAW values of ADC
2022-10-17 Typo on parenthesis
2022-10-17 Remove function get_time
2022-10-17 Suspect next_control_output to be buggy: check the limit actually.
2022-10-17 Update protocol
2022-10-17 Update function signatures to pass only the registers instead of all peripherals
2022-10-17 Update tool to show the voltage destination
2022-10-17 Remove software limit
2022-10-17 Black on files
2022-10-17 Remove calibration voltage
2022-10-17 Update requirements and setup file
2022-10-17 Update calibration scripts
2022-10-17 Update cargo and dependencies
2022-10-17 Slight change in UI
2022-10-17 Update comment and documentation
2022-11-30 Added board auto detection
2022-11-30 Rename "Silicon Toaster" to "SiliconToaster"
2022-11-30 Put "None" in tool.py as now there is "autodiscover"
2022-11-30 Create Silicon Toaster REST interface
2022-11-30 Continuous integration test
2023-05-17 Update heapless and pid crates
2023-05-17 Disable PID by default
2023-05-17 Use system timer to compute the delay
2023-05-17 In case of setting values, return the command byte to confirm execution
2023-05-17 Add control in tool to permit the change of PWM values
2023-05-17 ADC Control enabling commands
2023-05-17 [UI] ADC Control enabling commands
2023-05-17 Record 1024 rotating values of PID inputs, and get a function to retrieve them
2023-05-17 Shortcuts to activate/deactivate timer
2023-05-19 Initialize the PID with 150 as outputs limits
2023-05-19 Remove debug feature: record of ADC output
2023-05-19 Return systematically the command byte
2023-05-19 Format file and resolve clippy warnings
2023-05-19 Connect the button after being modified
2023-05-19 Change the next_control_output return value to give directly the PID output. Also ensure that the output limit is applied.
2023-05-19 Revert "Shortcuts to activate/deactivate timer"
    This reverts commit 8bfbbdd92279ec5402a5a34bf16261f0ad9dbc81.
2023-05-19 Set a maximum of 150 for the input inbox. Above this value it has been observed a crash of the STM32
2023-11-16 Updated PCB and gerber files
2023-12-07 Removed manual PWM settings
    Manual settings for PWM are not useful anymore thanks to the PID mode.
2023-12-07 Always enable PID
2023-12-07 Add thumbv6m target in CI
2023-12-07 Removed testing from CI
    Testing not possible for thumbv6m target
2024-02-08 Add clean for makefile
2024-02-09 Track possible errors of the set_pwm_parameters done by ADC
2024-02-09 Linting
2024-02-09 Rewording, and prevent data to be sent back
2024-02-09 Give a bit more comments
2024-02-09 Remove some typing warnings in editor
2024-03-08 Update configuration for compilation
2024-03-08 Migrate to pyQt6
2024-03-11 Move clamping to set_pw_parameters
2024-03-11 Include GUI in setup
2024-04-09 Adding LICENCE files
2024-05-24 Added readme
2024-05-24 Added link to the paper in readme
2024-05-24 Renamed hw folder to hardware
2025-01-02 Uploading contribution of Sven Freud to replace Current Sense Transformer
2025-01-02 Add contribution mention
2025-01-02 Slickscreen update
2025-01-02 Bump versions on documents
2025-03-27 Add building and flashing debug variant to makefile
2025-03-27 Use auto device detection in calibration scripts
    A single SiliconToaster which got prepared according to the ftdi/ folder
    will be detected automatically by SiliconToaster.
2025-03-27 Ignore raw flash images
2025-03-27 Disable ADC control/voltage controller for calibration
    The ADC contron/voltage controller overwrites PWM settings. It got
    introduced after the calibration scripts and needs to be disable before
    any raw PWM settings can take effect.
2025-03-27 Use Python interpreter from env/search path
    This allows to use a custom version and virtual environments
2025-03-27 Use Ledger's quicklog package from GitHub
    The quicklog package on PyPI is not the one you are looking for.
2025-09-24 Clean up USB devices used in firmware/makefile
    The device-specific port name from my FTDI device sneaked in
    accidentally.
2025-10-09 Spring cleaning for bringup tooling (#3)
    * Ignore raw flash images
    * Add building and flashing debug variant to makefile
    * Use Python interpreter from env/search path
    This allows to use a custom version and virtual environments
    * Disable ADC control/voltage controller for calibration
    The ADC contron/voltage controller overwrites PWM settings. It got
2025-10-21 Build and flash instructions
